FILESEXTRAPATHS:append := "${THISDIR}/${PN}:"
SRC_URI:append = " file://uboot.cfg "